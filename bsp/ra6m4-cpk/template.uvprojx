# Keil uVision project template.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA6M4AF Renesas
  pack: Renesas.RA_DFP.3.1.0
  cpu: CPUTYPE("Cortex-M33") FPU2 CLOCK(12000000) ELITTLE
  output: ra6m4 +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c SConscript
software components: Flex Software:RA Configuration 1.0.0
